Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcMember: SADEF-C+200X1.50 (118)
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Matériau | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
4 x POUTRE | STEEL/S235JR | +5.380 | +5.988 | A0(?) | 57 | 99 | S235JR | POUTRE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
2 x POUTRE | STEEL/S235JR | +5.479 | +5.988 | A0(?) | 59 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x POUTRE | STEEL/S235JR | +5.746 | +6.354 | A0(?) | 56 | 99 | S235JR | POUTRE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x POUTRE | STEEL/S235JR | +5.380 | +5.988 | A0(?) | 56 | 99 | S235JR | POUTRE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
2 x POUTRE | STEEL/S235JR | +5.784 | +6.293 | A0(?) | 60 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x POUTRE | STEEL/S235JR | +5.845 | +6.354 | A0(?) | 59 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x POUTRE | STEEL/S235JR | +5.784 | +6.293 | A0(?) | 59 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.548 | +6.171 | RA0(?) | 58 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +6.050 | +6.674 | RA0(?) | 58 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.898 | +6.521 | RA0(?) | 58 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.228 | +5.851 | RA0(?) | 58 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.076 | +5.699 | RA0(?) | 58 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +6.050 | +6.674 | RA0(?) | 57 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.898 | +6.521 | RA0(?) | 57 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.548 | +6.171 | RA0(?) | 57 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.228 | +5.851 | RA0(?) | 57 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.076 | +5.699 | RA0(?) | 57 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +6.050 | +6.674 | RA0(?) | 56 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.898 | +6.521 | RA0(?) | 56 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.228 | +5.851 | RA0(?) | 56 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x RENFORT-ATTACHE | STEEL/S235JR | +5.076 | +5.699 | RA0(?) | 56 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.548 | +6.171 | RA0(?) | 56 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
2 x RENFORT-ATTACHE | STEEL/S235JR | +6.149 | +6.674 | RA0(?) | 60 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.997 | +6.521 | RA0(?) | 60 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.647 | +6.171 | RA0(?) | 60 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.327 | +5.851 | RA0(?) | 60 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.174 | +5.699 | RA0(?) | 60 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x RENFORT-ATTACHE | STEEL/S235JR | +6.149 | +6.674 | RA0(?) | 59 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.997 | +6.521 | RA0(?) | 59 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.647 | +6.171 | RA0(?) | 59 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.327 | +5.851 | RA0(?) | 59 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x RENFORT-ATTACHE | STEEL/S235JR | +5.174 | +5.699 | RA0(?) | 59 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777

# IfcPlate: PL2*100 (20)
In: Undefined
Description: PL2*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PLA0(?); Repère d'assemblage: PLA0(?); Classe: 99; Matériau: S235JR; Profil: PL2*100; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 2 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PLA0(?)
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000004 m2
Name | Niveau bas | Niveau haut | Phase | Poids (kg) | Surface par tonne (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLAT | +0.179 | +0.279 | 1 | 0.5 | 130.8 | 300 | 0.0616 | 0.03 | 0.00006
2 x PLAT | +2.679 | +2.779 | 1 | 0.5 | 130.8 | 300 | 0.0616 | 0.03 | 0.00006
2 x PLAT | +4.856 | +4.956 | 1 | 0.5 | 130.8 | 300 | 0.0616 | 0.03 | 0.00006
2 x PLAT | +4.856 | +4.956 | 1 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008
2 x PLAT | +0.179 | +0.279 | 1 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008
2 x PLAT | +2.679 | +2.779 | 1 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008
2 x PLAT | +4.856 | +4.956 | 244 | 0.5 | 130.8 | 300 | 0.0616 | 0.03 | 0.00006
2 x PLAT | +4.856 | +4.956 | 244 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008
2 x PLAT | +0.179 | +0.279 | 244 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008
2 x PLAT | +2.679 | +2.779 | 244 | 0.6 | 130.6 | 400 | 0.082 | 0.04 | 0.00008

# IfcPlate: PL4*100 (12)
In: Undefined
Description: PL4*100; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: PL0(?); Repère d'assemblage: PL0(?); Classe: 99; Matériau: S235JR; Profil: PL4*100; Nom: PLAT
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 66.8 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 4 mm
Pset_PlateCommon - LoadBearing: yes; Reference: PL0(?)
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.000016 m2
Name | Niveau bas | Niveau haut | Phase | Poids (kg) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x PLAT | +5.458 | +5.517 | 62 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +5.660 | +5.719 | 62 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +5.999 | +6.058 | 62 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
2 x PLAT | +6.201 | +6.260 | 62 | 1.5 | 470 | 0.0985704 | 0.047005 | 0.00018802
4 x PLAT | +2.518 | +2.889 | 61 | 1.3 | 420 | 0.0881704 | 0.042005 | 0.00016802

# IfcPlate: PL4*162 (4)
In: Undefined
Description: PL4*162; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +5.897; Niveau haut: +6.120; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Classe: 99; Matériau: S235JR; Profil: PL4*162; Nom: GOUSSET
Tekla Quantités - Poids: 2.1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.9 m2; Surface nette: 0.1 m2; Hauteur: 161.8 mm; Largeur: 4 mm; Longueur: 418.2 mm
BaseQuantities - Width: 161.79 mm; NetArea: 0.139971 m2; GrossArea: 0.0676654 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000270662 m3; GrossVolume: 0.000270662 m3
Name | Phase
2 x GOUSSET | 60
2 x GOUSSET | 59

# IfcPlate: PL4*400 (4)
In: Undefined
Description: PL4*400; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +5.054; Niveau haut: +5.636; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Classe: 99; Matériau: S235JR; Profil: PL4*400; Nom: GOUSSET
Tekla Quantités - Poids: 6.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 400.2 mm; Largeur: 4 mm; Longueur: 582 mm
BaseQuantities - Width: 400.158 mm; NetArea: 0.448656 m2; GrossArea: 0.232894 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.000882055 m3; GrossVolume: 0.000882055 m3
Name | Phase
2 x GOUSSET | 60
2 x GOUSSET | 59

# IfcPlate: PL4*450 (2)
In: Undefined
Description: PL4*450; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +6.280; Niveau haut: +6.730; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Classe: 99; Matériau: S235JR; Profil: PL4*450; Nom: GOUSSET
Tekla Quantités - Poids: 8.4 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 450.1 mm; Largeur: 4 mm; Longueur: 697.2 mm
BaseQuantities - Width: 450.149 mm; NetArea: 0.543679 m2; GrossArea: 0.313841 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.0010708 m3; GrossVolume: 0.0010708 m3
Name | Phase
GOUSSET | 60
GOUSSET | 59

# IfcPlate: PL4*600 (6)
In: Undefined
Description: PL4*600; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +4.904; Niveau haut: +5.667; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Classe: 99; Matériau: S235JR; Profil: PL4*600; Nom: GOUSSET
Tekla Quantités - Poids: 13.5 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.5 m2; Surface nette: 0.9 m2; Hauteur: 600.2 mm; Largeur: 4 mm; Longueur: 762.8 mm
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
BaseQuantities - Width: 600.158 mm; NetArea: 0.870577 m2; GrossArea: 0.457815 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00172003 m3; GrossVolume: 0.00172003 m3
Name | Phase
2 x GOUSSET | 56
2 x GOUSSET | 57
2 x GOUSSET | 58

# IfcPlate: PL4*674 (3)
In: Undefined
Description: PL4*674; Material: STEEL/S235JR
Pset_PlateCommon - LoadBearing: yes; Reference: G0(?)
Tekla Commun - Niveau bas: +6.085; Niveau haut: +6.730; Repère de pièce: G0(?); Repère d'assemblage: G0(?); Classe: 99; Matériau: S235JR; Profil: PL4*674; Nom: GOUSSET
Tekla Quantités - Poids: 11.6 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.5 m2; Surface nette: 0.6 m2; Hauteur: 674.4 mm; Largeur: 4 mm; Longueur: 676.1 mm
BaseQuantities - Width: 674.407 mm; NetArea: 0.746343 m2; GrossArea: 0.455964 m2; CrossSectionArea: 0.000016 m2; NetVolume: 0.00147357 m3; GrossVolume: 0.00147357 m3
Name | Phase
GOUSSET | 56
GOUSSET | 57
GOUSSET | 58
