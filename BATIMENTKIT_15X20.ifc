Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: Tekla.ifc
Time: 2022-11-03T11:04:30
Author: RV-PC\W77
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla Structures 21.1, IFC Export Version: 4.0.0.0 Sep 11 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: PL2*100 (4)
In: Undefined
Description: PL2*100; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: An0(?); Repère d'assemblage: An0(?); Phase: 244; Classe: 7; Matériau: Steel_Undefined; Profil: PL2*100; Nom: Angle
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 130.4 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 2 mm; Longueur: 548 mm
Pset_BeamCommon - LoadBearing: yes; Reference: An0(?)
BaseQuantities - Length: 548 mm; OuterSurfaceArea: 0.1126 m2; NetVolume: 0.00011 m3; NetWeight: 0.8635 kg
Name | Niveau bas | Niveau haut
2 x Angle | +2.679 | +2.779
2 x Angle | +0.179 | +0.279

# IfcBeam: PL4*105 (42)
In: Undefined
Description: PL4*105; Material: STEEL/S235JR
Tekla Commun - Repère de pièce: AT0(?); Repère d'assemblage: AT0(?); Classe: 3; Matériau: S235JR; Profil: PL4*105; Nom: ATTACHE
Tekla Quantités - Poids: 1 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 67 m2; Surface nette: 0.1 m2; Hauteur: 105 mm; Largeur: 4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: AT0(?)
Name | Niveau bas | Niveau haut | Phase | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
6 x ATTACHE | +5.440 | +5.549 | 54 | 292 | 292.003 | 0.0653687 | 0.000124321 | 0.975923
6 x ATTACHE | +5.258 | +5.287 | 54 | 292 | 292.003 | 0.0653687 | 0.000124321 | 0.975923
ATTACHE | -5.287 | -5.258 | 54 | 292 | 292.003 | 0.0653687 | 0.000124321 | 0.975923
2 x ATTACHE | +6.558 | +6.670 | 58 | 311.9 | 311.913 | 0.0697091 | 0.000132684 | 1.04157
2 x ATTACHE | +6.558 | +6.670 | 57 | 311.9 | 311.913 | 0.0697091 | 0.000132684 | 1.04157
2 x ATTACHE | +6.558 | +6.670 | 56 | 311.9 | 311.913 | 0.0697091 | 0.000132684 | 1.04157
2 x ATTACHE | +6.181 | +6.292 | 58 | 305 | 305.003 | 0.0682027 | 0.000129781 | 1.01878
2 x ATTACHE | +5.812 | +5.922 | 58 | 305 | 305.003 | 0.0682027 | 0.000129781 | 1.01878
2 x ATTACHE | +5.812 | +5.922 | 57 | 305 | 305.003 | 0.0682027 | 0.000129781 | 1.01878
ATTACHE | +6.181 | +6.292 | 57 | 305 | 305.003 | 0.0682027 | 0.000129781 | 1.01878
2 x ATTACHE | +6.181 | +6.292 | 56 | 305 | 305.003 | 0.0682027 | 0.000129781 | 1.01878
2 x ATTACHE | +5.812 | +5.922 | 56 | 305 | 305.003 | 0.0682027 | 0.000129781 | 1.01878
6 x ATTACHE | +2.679 | +2.722 | 1 | 305 | 305.003 | 0.0682027 | 0.000129781 | 1.01878
6 x ATTACHE | +0.179 | +0.222 | 1 | 305 | 305.003 | 0.0682027 | 0.000129781 | 1.01878

# IfcBeam: PL4*150 (16)
In: Undefined
Description: PL4*150; Material: STEEL/Steel_Undefined
Pset_BeamCommon - LoadBearing: yes; Reference: A0(?)
Tekla Commun - Repère de pièce: A0(?); Repère d'assemblage: A0(?); Matériau: Steel_Undefined; Profil: PL4*150; Nom: AT CROIX
Tekla Quantités - Poids: 2.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.8 m2; Surface nette: 0.2 m2; Hauteur: 150 mm; Largeur: 4 mm; Longueur: 602 mm
BaseQuantities - Length: 602 mm; OuterSurfaceArea: 0.18908 m2; NetVolume: 0.000366 m3; NetWeight: 2.8731 kg
Name | Niveau bas | Niveau haut | Phase | Classe
4 x AT CROIX | +5.211 | +5.442 | 62 | 6
4 x AT CROIX | +6.277 | +6.508 | 62 | 6
4 x AT CROIX | +4.953 | +5.103 | 61 | 99
4 x AT CROIX | +0.304 | +0.454 | 61 | 99

# IfcBeam: PL4*200 (60)
In: Undefined
Description: PL4*200; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: AT0(?)
Tekla Commun - Repère de pièce: AT0(?); Repère d'assemblage: AT0(?); Classe: 99; Matériau: S235JR; Profil: PL4*200; Nom: ATTACHE
Tekla Quantités - Poids: 1.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 66.2 m2; Surface nette: 0.1 m2; Hauteur: 200 mm; Largeur: 4 mm
Name | Niveau bas | Niveau haut | Phase | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
4 x ATTACHE | +2.632 | +2.679 | 54 | 209 | 209.003 | 0.0885053 | 0.000170403 | 1.33766
4 x ATTACHE | +0.132 | +0.179 | 54 | 209 | 209.003 | 0.0885053 | 0.000170403 | 1.33766
14 x ATTACHE | +5.209 | +5.256 | 54 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +6.519 | +6.724 | 60 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +5.398 | +5.603 | 60 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
6 x ATTACHE | +6.519 | +6.724 | 53 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
12 x ATTACHE | +5.398 | +5.603 | 53 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
4 x ATTACHE | +4.809 | +4.856 | 54 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
4 x ATTACHE | +2.632 | +2.679 | 54 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
4 x ATTACHE | +0.132 | +0.179 | 54 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +6.519 | +6.724 | 59 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254
2 x ATTACHE | +5.398 | +5.603 | 59 | 205 | 205.003 | 0.0868733 | 0.000167203 | 1.31254

# IfcBeam: PL4*250 (20)
In: Undefined
Description: PL4*250; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
Tekla Commun - Niveau bas: +0.000; Niveau haut: +0.054; Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Phase: 54; Classe: 99; Matériau: S235JR; Profil: PL4*250; Nom: CORNIERE
Tekla Quantités - Poids: 0.8 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 67.2 m2; Surface nette: 0.1 m2; Hauteur: 250 mm; Largeur: 4 mm; Longueur: 100 mm
BaseQuantities - Length: 100 mm; OuterSurfaceArea: 0.054832 m2; NetVolume: 0.000104 m3; NetWeight: 0.8164 kg

# IfcBeam: PL4*300 (20)
In: Undefined
Description: PL4*300; Material: STEEL/S235JR
Pset_BeamCommon - LoadBearing: yes; Reference: AT0(?)
Tekla Commun - Repère de pièce: AT0(?); Repère d'assemblage: AT0(?); Phase: 54; Classe: 99; Matériau: S235JR; Profil: PL4*300; Nom: ATTACHE
Tekla Quantités - Poids: 2 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 65.8 m2; Surface nette: 0.1 m2; Hauteur: 300 mm; Largeur: 4 mm; Longueur: 205 mm
BaseQuantities - Length: 205.003 mm; OuterSurfaceArea: 0.129474 m2; NetVolume: 0.000250804 m3; NetWeight: 1.96881 kg
Name | Niveau bas | Niveau haut
4 x ATTACHE | +0.132 | +0.179
6 x ATTACHE | +2.632 | +2.679
8 x ATTACHE | +4.809 | +4.856
2 x ATTACHE | +5.056 | +5.103

# IfcBeam: PL4*360 (4)
In: Undefined
Description: PL4*360; Material: STEEL/Steel_Undefined
Tekla Commun - Niveau bas: +5.728; Niveau haut: +5.991; Repère de pièce: A0(?); Repère d'assemblage: A0(?); Phase: 62; Classe: 6; Matériau: Steel_Undefined; Profil: PL4*360; Nom: AT CROIX
Tekla Quantités - Poids: 6.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 64.8 m2; Surface nette: 0.4 m2; Hauteur: 360 mm; Largeur: 4 mm; Longueur: 602 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A0(?)
BaseQuantities - Length: 602 mm; OuterSurfaceArea: 0.44696 m2; NetVolume: 0.0008784 m3; NetWeight: 6.89544 kg

# IfcBeam: PL4*400 (8)
In: Undefined
Description: PL4*400; Material: STEEL/S235JR
Tekla Commun - Niveau bas: +0.000; Niveau haut: +0.054; Repère de pièce: CO0(?); Repère d'assemblage: CO0(?); Classe: 99; Matériau: S235JR; Profil: PL4*400; Nom: CORNIERE
Tekla Quantités - Poids: 1.3 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 66.8 m2; Surface nette: 0.1 m2; Hauteur: 400 mm; Largeur: 4 mm; Longueur: 100 mm
Pset_BeamCommon - LoadBearing: yes; Reference: CO0(?)
BaseQuantities - Length: 100 mm; OuterSurfaceArea: 0.087232 m2; NetVolume: 0.0001664 m3; NetWeight: 1.30624 kg
Name | Phase
6 x CORNIERE | 54
2 x CORNIERE | 243

# IfcBeam: SADEF-C+200X1.50 (135)
In: Undefined
Description: SADEF-C+200X1.50
Tekla Commun - Profil: SADEF-C+200X1.50
Tekla Quantités - Volume: 0 m3; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Matériau | Nom | Poids (kg) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
LISSE | STEEL/S235JR | +4.956 | +5.056 | LS0(?) | 54 | 14 | S235JR | LISSE | 28.4 | 1 | 5.1 | 5012.4 | 5012.44 | 4.3107 | 0.0037894 | 29.7468
2 x ARBA | STEEL/Steel_Undefined | +5.217 | +5.687 | A0(?) | 62 | 6 | Steel_Undefined | ARBA | 16.2 | 0 | 2.9 | 2856.2 | 2856.16 | 2.4563 | 0.00215926 | 16.9502
2 x ARBA | STEEL/Steel_Undefined | +5.217 | +5.958 | A0(?) | 62 | 6 | Steel_Undefined | ARBA | 33.1 | 0 | 6 | 5839.1 | 5839.14 | 5.02166 | 0.00441439 | 34.6529
2 x ARBA | STEEL/Steel_Undefined | +5.490 | +5.958 | A0(?) | 62 | 6 | Steel_Undefined | ARBA | 16.2 | 0 | 2.9 | 2838.9 | 2838.9 | 2.44146 | 0.00214621 | 16.8477
2 x ARBA | STEEL/Steel_Undefined | +5.761 | +6.228 | A0(?) | 62 | 6 | Steel_Undefined | ARBA | 16 | 0 | 2.9 | 2826.2 | 2826.16 | 2.4305 | 0.00213658 | 16.7722
2 x ARBA | STEEL/Steel_Undefined | +5.761 | +6.502 | A0(?) | 62 | 6 | Steel_Undefined | ARBA | 33.1 | 0 | 6 | 5839.1 | 5839.14 | 5.02166 | 0.00441439 | 34.6529
2 x ARBA | STEEL/Steel_Undefined | +6.031 | +6.502 | A0(?) | 62 | 6 | Steel_Undefined | ARBA | 16.3 | 0 | 2.9 | 2868.9 | 2868.9 | 2.46726 | 0.00216889 | 17.0258
2 x PANNE | STEEL/S235JR | +6.126 | +6.339 | PA0(?) | 53 | 5 | S235JR | PANNE | 27.7 | 0 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
12 x RENFORT-ATTACHE | STEEL/S235JR | +2.579 | +2.679 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.1 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 3.56076
12 x RENFORT-ATTACHE | STEEL/S235JR | +0.079 | +0.179 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.1 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 3.56076
6 x RENFORT-ATTACHE | STEEL/S235JR | +4.679 | +4.879 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.1 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 3.56076
6 x RENFORT-ATTACHE | STEEL/S235JR | +1.179 | +1.379 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.1 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 3.56076
6 x RENFORT-ATTACHE | STEEL/S235JR | +3.579 | +3.779 | RA0(?) | 48 | 99 | S235JR | RENFORT-ATTACHE | 3.4 | 0.1 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 3.56076
4 x RENFORT-ATTACHE | STEEL/S235JR | +1.179 | +1.379 | RA0(?) | 50 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.1 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 2.9673
4 x RENFORT-ATTACHE | STEEL/S235JR | +3.579 | +3.779 | RA0(?) | 50 | 99 | S235JR | RENFORT-ATTACHE | 2.8 | 0.1 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 2.9673
LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 54 | 14 | S235JR | LISSE | 28.4 | 0.4 | 5.1 | 5012.4 | 5012.44 | 4.3107 | 0.0037894 | 29.7468
LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 54 | 14 | S235JR | LISSE | 28.4 | 0.4 | 5.1 | 5012.4 | 5012.44 | 4.3107 | 0.0037894 | 29.7468
2 x LISSE | STEEL/S235JR | +4.856 | +4.956 | LS0(?) | 54 | 14 | S235JR | LISSE | 28.4 | 0.4 | 5.1 | 5012.4 | 5012.44 | 4.3107 | 0.0037894 | 29.7468
4 x LISSE | STEEL/S235JR | +4.856 | +4.956 | LS0(?) | 54 | 14 | S235JR | LISSE | 24.9 | 0.4 | 4.4 | 4378.8 | 4378.79 | 3.76576 | 0.00331037 | 25.9864
4 x LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 54 | 14 | S235JR | LISSE | 24.9 | 0.4 | 4.4 | 4378.8 | 4378.79 | 3.76576 | 0.00331037 | 25.9864
4 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 54 | 14 | S235JR | LISSE | 24.9 | 0.4 | 4.4 | 4378.8 | 4378.79 | 3.76576 | 0.00331037 | 25.9864
4 x PANNE | STEEL/S235JR | +5.760 | +5.973 | PA0(?) | 53 | 5 | S235JR | PANNE | 27.1 | 0 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
2 x LISSE | STEEL/S235JR | +5.256 | +5.356 | LS0(?) | 54 | 14 | S235JR | LISSE | 28.3 | 0.4 | 4.9 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 54 | 14 | S235JR | LISSE | 28.3 | 0.4 | 4.9 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 54 | 14 | S235JR | LISSE | 28.3 | 0.4 | 4.9 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +6.504 | +6.717 | PA0(?) | 53 | 5 | S235JR | PANNE | 28.3 | 0 | 4.9 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +6.126 | +6.339 | PA0(?) | 53 | 5 | S235JR | PANNE | 28.3 | 0 | 4.9 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +5.760 | +5.973 | PA0(?) | 53 | 5 | S235JR | PANNE | 28.3 | 0 | 4.9 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +5.383 | +5.596 | PA0(?) | 53 | 5 | S235JR | PANNE | 28.3 | 0 | 4.9 | 4982 | 4982 | 4.28452 | 0.00376639 | 29.5662
2 x PANNE | STEEL/S235JR | +6.504 | +6.717 | PA0(?) | 53 | 5 | S235JR | PANNE | 27.7 | 0 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x PANNE | STEEL/S235JR | +5.760 | +5.973 | PA0(?) | 53 | 5 | S235JR | PANNE | 27.7 | 0 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x PANNE | STEEL/S235JR | +5.383 | +5.596 | PA0(?) | 53 | 5 | S235JR | PANNE | 27.7 | 0 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x LISSE | STEEL/S235JR | +5.256 | +5.356 | LS0(?) | 54 | 14 | S235JR | LISSE | 27.7 | 0.4 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 54 | 14 | S235JR | LISSE | 27.7 | 0.4 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
2 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 54 | 14 | S235JR | LISSE | 27.7 | 0.4 | 4.9 | 4882 | 4882 | 4.19852 | 0.00369079 | 28.9727
4 x LISSE | STEEL/S235JR | +0.179 | +0.279 | LS0(?) | 54 | 14 | S235JR | LISSE | 27.1 | 0.4 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x LISSE | STEEL/S235JR | +2.679 | +2.779 | LS0(?) | 54 | 14 | S235JR | LISSE | 27.1 | 0.4 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x LISSE | STEEL/S235JR | +5.256 | +5.356 | LS0(?) | 54 | 14 | S235JR | LISSE | 27.1 | 0.4 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x PANNE | STEEL/S235JR | +6.126 | +6.339 | PA0(?) | 53 | 5 | S235JR | PANNE | 27.1 | 0 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x PANNE | STEEL/S235JR | +6.504 | +6.717 | PA0(?) | 53 | 5 | S235JR | PANNE | 27.1 | 0 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793
4 x PANNE | STEEL/S235JR | +5.383 | +5.596 | PA0(?) | 53 | 5 | S235JR | PANNE | 27.1 | 0 | 4.9 | 4782 | 4782 | 4.11252 | 0.00361519 | 28.3793

# IfcBeam: SADEF-C+200X2.00 (43)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POTEAU | -0.400 | +5.903 | P0(?) | 48 | 3 | POTEAU | 47.8 | 6.4 | 6303.3 | 6303.33 | 5.42086 | 0.00632854 | 49.6791
2 x POTEAU | -0.400 | +6.097 | P0(?) | 48 | 3 | POTEAU | 49.3 | 6.6 | 6496.8 | 6496.81 | 5.58726 | 0.0065228 | 51.204
2 x ARBA | +5.205 | +6.522 | AB0(?) | 60 | 7 | ARBA | 55.7 | 7.4 | 7348 | 7347.97 | 6.31925 | 0.00737736 | 57.9123
2 x ARBA | +5.377 | +6.725 | AB0(?) | 60 | 7 | ARBA | 57.3 | 7.6 | 7553.9 | 7553.89 | 6.49635 | 0.00758411 | 59.5352
2 x ARBA | +5.205 | +6.522 | AB0(?) | 59 | 7 | ARBA | 55.7 | 7.4 | 7348 | 7347.97 | 6.31925 | 0.00737736 | 57.9123
2 x ARBA | +5.377 | +6.725 | AB0(?) | 59 | 7 | ARBA | 57.3 | 7.6 | 7553.9 | 7553.89 | 6.49635 | 0.00758411 | 59.5352
2 x ARBA | +5.034 | +6.320 | AB0(?) | 58 | 7 | ARBA | 54.2 | 7.2 | 7147.7 | 7147.74 | 6.14706 | 0.00717633 | 56.3342
2 x ARBA | +5.205 | +6.522 | AB0(?) | 58 | 7 | ARBA | 55.7 | 7.4 | 7348 | 7347.97 | 6.31925 | 0.00737736 | 57.9123
2 x ARBA | +5.377 | +6.725 | AB0(?) | 58 | 7 | ARBA | 57.3 | 7.6 | 7553.9 | 7553.89 | 6.49635 | 0.00758411 | 59.5352
2 x ARBA | +5.034 | +6.320 | AB0(?) | 56 | 7 | ARBA | 54.2 | 7.2 | 7147.7 | 7147.74 | 6.14706 | 0.00717633 | 56.3342
2 x ARBA | +5.205 | +6.522 | AB0(?) | 56 | 7 | ARBA | 55.7 | 7.4 | 7348 | 7347.97 | 6.31925 | 0.00737736 | 57.9123
2 x ARBA | +5.377 | +6.725 | AB0(?) | 56 | 7 | ARBA | 57.3 | 7.6 | 7553.9 | 7553.89 | 6.49635 | 0.00758411 | 59.5352
2 x ARBA | +5.034 | +6.320 | AB0(?) | 57 | 7 | ARBA | 54.2 | 7.2 | 7147.7 | 7147.74 | 6.14706 | 0.00717633 | 56.3342
2 x ARBA | +5.205 | +6.522 | AB0(?) | 57 | 7 | ARBA | 55.7 | 7.4 | 7348 | 7347.97 | 6.31925 | 0.00737736 | 57.9123
2 x ARBA | +5.377 | +6.725 | AB0(?) | 57 | 7 | ARBA | 57.3 | 7.6 | 7553.9 | 7553.89 | 6.49635 | 0.00758411 | 59.5352
3 x POTEAU | -0.600 | +5.029 | P0(?) | 48 | 3 | POTEAU | 42.7 | 5.7 | 5628.7 | 5628.65 | 4.84064 | 0.00565116 | 44.3616
5 x POTEAU | -0.600 | +5.200 | P0(?) | 48 | 3 | POTEAU | 44 | 5.8 | 5800.3 | 5800.26 | 4.98822 | 0.00582346 | 45.7142
5 x POTEAU | -0.600 | +5.367 | P0(?) | 48 | 3 | POTEAU | 45.2 | 6 | 5967 | 5967 | 5.13162 | 0.00599087 | 47.0283

# IfcColumn: SADEF-C+200X2.00 (17)
In: Undefined
Description: SADEF-C+200X2.00; Material: STEEL/Steel_Undefined
Tekla Commun - Repère de pièce: P0(?); Repère d'assemblage: P0(?); Phase: 48; Classe: 3; Matériau: Steel_Undefined; Profil: SADEF-C+200X2.00; Nom: POTEAU
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 113.4 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: P0(?)
Name | Niveau bas | Niveau haut | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3) | NetWeight (kg)
2 x POTEAU | -0.400 | +5.903 | 47.8 | 6.4 | 6303.3 | 6303.33 | 5.42086 | 0.00632854 | 49.6791
2 x POTEAU | -0.400 | +6.097 | 49.3 | 6.6 | 6496.8 | 6496.81 | 5.58726 | 0.0065228 | 51.204
3 x POTEAU | -0.600 | +5.029 | 42.7 | 5.7 | 5628.7 | 5628.65 | 4.84064 | 0.00565116 | 44.3616
5 x POTEAU | -0.600 | +5.200 | 44 | 5.8 | 5800.3 | 5800.26 | 4.98822 | 0.00582346 | 45.7142
5 x POTEAU | -0.600 | +5.367 | 45.2 | 6 | 5967 | 5967 | 5.13162 | 0.00599087 | 47.0283

# IfcElementAssembly (566)
In: Undefined
Name | PredefinedType | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
Steel Assembly | RIGID_FRAME | 1 | +5.440 | +5.549 | 2/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.440 | +5.549 | 3/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.440 | +5.549 | 4/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.440 | +5.549 | 2/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.440 | +5.549 | 3/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.440 | +5.549 | 4/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.258 | +5.287 | 2/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | -5.287 | -5.258 | 2/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 6.9 | +5.728 | +5.991 | 3/A-B | A0(?) | 210
Steel Assembly | RIGID_FRAME | 6.9 | +5.728 | +5.991 | 2/A-B | A0(?) | 210
2 x Steel Assembly | RIGID_FRAME | 1 | +6.558 | +6.670 | 4/C | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 1 | +6.558 | +6.670 | 3/C | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 1 | +6.558 | +6.670 | 2/C | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 2 | +0.132 | +0.179 | 5/D | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 2 | +2.632 | +2.679 | 5/B | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 2 | +2.632 | +2.679 | 5/D | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 2 | +4.809 | +4.856 | 5/B | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 2 | +4.809 | +4.856 | 5/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 2 | +0.132 | +0.179 | 1/B | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 2 | +4.809 | +4.856 | 1/B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 2 | +2.632 | +2.679 | 1/B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 2 | +0.132 | +0.179 | 1/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 0.5 | +0.179 | +0.279 | 5/B | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +0.179 | +0.279 | 5/D | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +2.679 | +2.779 | 5/B | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +2.679 | +2.779 | 5/D | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +4.856 | +4.956 | 5/B | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +4.856 | +4.956 | 5/D | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +4.856 | +4.956 | 5/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 5/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.679 | +2.779 | 5/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +4.856 | +4.956 | 5/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 5/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.679 | +2.779 | 5/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +4.856 | +4.956 | 1/B | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.5 | +4.856 | +4.956 | 1/D | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 1 | +2.679 | +2.779 | 1/B | An0(?) | 251
Steel Assembly | RIGID_FRAME | 1 | +0.179 | +0.279 | 1/B | An0(?) | 251
Steel Assembly | RIGID_FRAME | 1 | +2.679 | +2.779 | 1/D | An0(?) | 251
Steel Assembly | RIGID_FRAME | 1 | +0.179 | +0.279 | 1/D | An0(?) | 251
Steel Assembly | RIGID_FRAME | 0.6 | +4.856 | +4.956 | 1/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 1/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.679 | +2.779 | 1/A | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +4.856 | +4.956 | 1/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +0.179 | +0.279 | 1/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 0.6 | +2.679 | +2.779 | 1/E | PLA0(?) | 2
Steel Assembly | RIGID_FRAME | 47.8 | -0.400 | +5.903 | 5/D | P0(?) | 100
Steel Assembly | RIGID_FRAME | 49.3 | -0.400 | +6.097 | 5/D | P0(?) | 100
Steel Assembly | RIGID_FRAME | 47.8 | -0.400 | +5.903 | 5/B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 49.3 | -0.400 | +6.097 | 5/B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 47.8 | -0.400 | +5.903 | 1/D | P0(?) | 100
Steel Assembly | RIGID_FRAME | 49.3 | -0.400 | +6.097 | 1/D | P0(?) | 100
Steel Assembly | RIGID_FRAME | 47.8 | -0.400 | +5.903 | 1/B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 49.3 | -0.400 | +6.097 | 1/B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 2 | +5.056 | +5.103 | 1/B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 2 | +5.056 | +5.103 | 1/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 28.4 | +4.956 | +5.056 | 1/B-D | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +0.000 | +0.054 | 5/B | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 1.3 | +0.000 | +0.054 | 5/D | CO0(?) | 54
Steel Assembly |  | 86.1 | -0.450 | -0.000 | 5/B | S0(?) | 275
Steel Assembly |  | 1295.4 | -0.800 | -0.000 | 4-5/A-B | S0(?) | 800
Steel Assembly |  | 86.1 | -0.450 | -0.000 | 5/D | S0(?) | 275
Steel Assembly |  | 1295.4 | -0.800 | -0.000 | 4-5/D-E | S0(?) | 800
Steel Assembly |  | 86.1 | -0.450 | -0.000 | 1/B | S0(?) | 275
Steel Assembly |  | 1295.4 | -0.800 | -0.000 | 1-2/A-B | S0(?) | 800
Steel Assembly |  | 86.1 | -0.450 | -0.000 | 1/D | S0(?) | 275
Steel Assembly |  | 1295.4 | -0.800 | -0.000 | 1-2/D-E | S0(?) | 800
Steel Assembly |  | 139 | -0.650 | -0.000 | 5/D-E | S0(?) | 130
2 x Steel Assembly |  | 2530 | -1.000 | -0.000 | 4-5/D-E | S0(?) | 1000
Steel Assembly |  | 139 | -0.650 | -0.000 | 5/A-B | S0(?) | 130
2 x Steel Assembly |  | 2530 | -1.000 | -0.000 | 4-5/A-B | S0(?) | 1000
Steel Assembly |  | 139 | -0.650 | -0.000 | 4/D-E | S0(?) | 130
Steel Assembly |  | 139 | -0.650 | -0.000 | 4/A-B | S0(?) | 130
Steel Assembly |  | 139 | -0.650 | -0.000 | 3/D-E | S0(?) | 130
2 x Steel Assembly |  | 2530 | -1.000 | -0.000 | 2-3/D-E | S0(?) | 1000
Steel Assembly |  | 139 | -0.650 | -0.000 | 3/A-B | S0(?) | 130
2 x Steel Assembly |  | 2530 | -1.000 | -0.000 | 2-3/A-B | S0(?) | 1000
Steel Assembly |  | 139 | -0.650 | -0.000 | 2/D-E | S0(?) | 130
Steel Assembly |  | 139 | -0.650 | -0.000 | 2/A-B | S0(?) | 130
Steel Assembly |  | 139 | -0.650 | -0.000 | 1/D-E | S0(?) | 130
Steel Assembly |  | 2530 | -1.000 | -0.000 | 1-2/D-E | S0(?) | 1000
Steel Assembly |  | 139 | -0.650 | -0.000 | 1/A-B | S0(?) | 130
Steel Assembly |  | 2530 | -1.000 | -0.000 | 1-2/A-B | S0(?) | 1000
2 x Steel Assembly | RIGID_FRAME | 2 | +4.809 | +4.856 | 1/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 2/D-E | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 3/D-E | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 1/E | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 4/D-E | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 5/E | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 2/A-B | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 3/A-B | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 1/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 4/A-B | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 5/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 2/D-E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 2/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 2/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 3/D-E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 3/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 3/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 3/A-B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 3/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 3/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 2/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 1/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 1/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 1/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 1/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 5/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 5/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 5/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 5/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 2/A-B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 2/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 4/D-E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 4/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 4/E | P0(?) | 100
Steel Assembly | RIGID_FRAME | 42.7 | -0.600 | +5.029 | 4/A-B | P0(?) | 100
Steel Assembly | RIGID_FRAME | 44 | -0.600 | +5.200 | 4/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 45.2 | -0.600 | +5.367 | 4/A | P0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 5/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 5/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 1/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 1/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 54.2 | +5.034 | +6.320 | 4/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 4/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 4/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 54.2 | +5.034 | +6.320 | 2/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 2/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 2/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 54.2 | +5.034 | +6.320 | 3/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 3/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 3/C-E | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 4/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 2/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 3/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 5/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 5/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 55.7 | +5.205 | +6.522 | 1/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 1/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 54.2 | +5.034 | +6.320 | 4/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 4/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 54.2 | +5.034 | +6.320 | 2/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 2/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 54.2 | +5.034 | +6.320 | 3/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 57.3 | +5.377 | +6.725 | 3/A-C | AB0(?) | 100
Steel Assembly | RIGID_FRAME | 13.5 | +4.904 | +5.667 | 2/D-E | G0(?) | 4
Steel Assembly | RIGID_FRAME | 13.5 | +4.904 | +5.667 | 3/D-E | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.9 | +5.211 | +5.442 | 3/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 16.2 | +5.217 | +5.687 | 2-3/D-E | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 2.9 | +6.277 | +6.508 | 3/C | A0(?) | 210
Steel Assembly | RIGID_FRAME | 16.3 | +6.031 | +6.502 | 2-3/C-D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +5.211 | +5.442 | 2/E | A0(?) | 210
2 x Steel Assembly | RIGID_FRAME | 2.9 | +6.277 | +6.508 | 2/C | A0(?) | 210
Steel Assembly | RIGID_FRAME | 6.9 | +5.728 | +5.991 | 3/D-E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 6.9 | +5.728 | +5.991 | 2/D-E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 33.1 | +5.217 | +5.958 | 2-3/D-E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +5.490 | +5.958 | 2-3/D-E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.5 | +5.458 | +5.517 | 2-3/D-E | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.5 | +5.660 | +5.719 | 2-3/D-E | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 16 | +5.761 | +6.228 | 2-3/C-E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.5 | +5.999 | +6.058 | 2-3/C-D | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.5 | +6.201 | +6.260 | 2-3/C-D | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 33.1 | +5.761 | +6.502 | 2-3/C-E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +5.211 | +5.442 | 3/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +5.211 | +5.442 | 2/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 16.2 | +5.217 | +5.687 | 2-3/A-B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 33.1 | +5.217 | +5.958 | 2-3/A-B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 16.2 | +5.490 | +5.958 | 2-3/A-B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.5 | +5.458 | +5.517 | 2-3/A-B | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.5 | +5.660 | +5.719 | 2-3/A-B | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 16 | +5.761 | +6.228 | 2-3/A-C | A0(?) | 100
Steel Assembly | RIGID_FRAME | 16.3 | +6.031 | +6.502 | 2-3/B-C | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1.5 | +5.999 | +6.058 | 2-3/B-C | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 1.5 | +6.201 | +6.260 | 2-3/B-C | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 33.1 | +5.761 | +6.502 | 2-3/A-C | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +2.518 | +2.889 | 2-3/E | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 18.7 | +0.255 | +2.695 | 2-3/E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +4.953 | +5.103 | 2/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 18.7 | +2.712 | +5.146 | 2-3/E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +4.953 | +5.103 | 3/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +0.304 | +0.454 | 3/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +0.304 | +0.454 | 2/E | A0(?) | 210
Steel Assembly | RIGID_FRAME | 38.1 | +0.255 | +5.146 | 2-3/E | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +2.518 | +2.889 | 2-3/A | PL0(?) | 4
Steel Assembly | RIGID_FRAME | 38.1 | +0.255 | +5.146 | 2-3/A | A0(?) | 100
Steel Assembly | RIGID_FRAME | 18.7 | +0.255 | +2.695 | 2-3/A | A0(?) | 100
Steel Assembly | RIGID_FRAME | 18.7 | +2.712 | +5.146 | 2-3/A | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.9 | +4.953 | +5.103 | 2/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +4.953 | +5.103 | 3/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +0.304 | +0.454 | 3/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 2.9 | +0.304 | +0.454 | 2/A | A0(?) | 210
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 5/E | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 5/E | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 1/E | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 1/E | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 1/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 5/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 5/A | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 5/A | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 2.8 | +5.479 | +5.988 | 5/D-E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.479 | +5.988 | 5/A-B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.845 | +6.354 | 5/D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.845 | +6.354 | 5/B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.519 | +6.724 | 5/C | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 5/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 5/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.746 | +6.354 | 4/D | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.380 | +5.988 | 4/D-E | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.746 | +6.354 | 4/B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.380 | +5.988 | 4/A-B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.519 | +6.724 | 4/C | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 4/E | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 4/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 3/E | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 3/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.746 | +6.354 | 3/D | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.380 | +5.988 | 3/D-E | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.746 | +6.354 | 3/B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.380 | +5.988 | 3/A-B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.519 | +6.724 | 3/C | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1 | +6.181 | +6.292 | 4/D | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.812 | +5.922 | 4/D-E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +6.181 | +6.292 | 4/B | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.812 | +5.922 | 4/A-B | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.812 | +5.922 | 3/D-E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +6.181 | +6.292 | 3/B | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.812 | +5.922 | 3/A-B | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +6.181 | +6.292 | 2/D | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.812 | +5.922 | 2/D-E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +6.181 | +6.292 | 2/B | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.812 | +5.922 | 2/A-B | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 2.8 | +5.479 | +5.988 | 1/D-E | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.479 | +5.988 | 1/A-B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.746 | +6.354 | 2/D | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.380 | +5.988 | 2/D-E | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.746 | +6.354 | 2/B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.380 | +5.988 | 2/A-B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 1 | +2.679 | +2.722 | 3/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +0.179 | +0.222 | 3/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +2.679 | +2.722 | 3/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +0.179 | +0.222 | 3/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 2.1 | +5.897 | +6.120 | 5/D | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.8 | +5.784 | +6.293 | 5/D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.1 | +5.897 | +6.120 | 5/B | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.8 | +5.784 | +6.293 | 5/B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.845 | +6.354 | 1/D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.1 | +5.897 | +6.120 | 1/D | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.8 | +5.784 | +6.293 | 1/D | A0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.845 | +6.354 | 1/B | A0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +6.126 | +6.339 | 1-2/B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.1 | +5.897 | +6.120 | 1/B | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.8 | +5.784 | +6.293 | 1/B | A0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.548 | +6.171 | 4/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.050 | +6.674 | 4/C-D | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.898 | +6.521 | 4/C-D | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.228 | +5.851 | 4/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.076 | +5.699 | 4/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.548 | +6.171 | 4/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.050 | +6.674 | 4/B-C | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.898 | +6.521 | 4/B-C | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.228 | +5.851 | 4/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.076 | +5.699 | 4/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.050 | +6.674 | 3/C-D | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.898 | +6.521 | 3/C-D | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +5.548 | +6.171 | 3/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.228 | +5.851 | 3/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.076 | +5.699 | 3/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.050 | +6.674 | 3/B-C | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.898 | +6.521 | 3/B-C | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +5.548 | +6.171 | 3/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.228 | +5.851 | 3/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.076 | +5.699 | 3/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +2.579 | +2.679 | 4/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.050 | +6.674 | 2/C-D | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.898 | +6.521 | 2/C-D | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.228 | +5.851 | 2/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.076 | +5.699 | 2/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +6.050 | +6.674 | 2/B-C | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.898 | +6.521 | 2/B-C | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.228 | +5.851 | 2/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +5.076 | +5.699 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +5.548 | +6.171 | 2/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +5.548 | +6.171 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.149 | +6.674 | 5/C-D | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.997 | +6.521 | 5/C-D | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.647 | +6.171 | 5/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.327 | +5.851 | 5/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.174 | +5.699 | 5/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.149 | +6.674 | 5/B-C | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.997 | +6.521 | 5/B-C | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.647 | +6.171 | 5/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.327 | +5.851 | 5/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.174 | +5.699 | 5/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.149 | +6.674 | 1/C-D | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.997 | +6.521 | 1/C-D | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.647 | +6.171 | 1/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.327 | +5.851 | 1/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.174 | +5.699 | 1/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +6.149 | +6.674 | 1/B-C | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.997 | +6.521 | 1/B-C | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.647 | +6.171 | 1/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.327 | +5.851 | 1/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +5.174 | +5.699 | 1/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +0.079 | +0.179 | 4/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +2.579 | +2.679 | 3/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +0.079 | +0.179 | 3/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +2.579 | +2.679 | 2/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +0.079 | +0.179 | 2/D-E | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +2.579 | +2.679 | 4/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +0.079 | +0.179 | 4/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +2.579 | +2.679 | 3/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +0.079 | +0.179 | 3/A-B | RA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 3.4 | +2.579 | +2.679 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +4.679 | +4.879 | 4/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 4/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 4/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +4.679 | +4.879 | 3/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 3/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 3/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +4.679 | +4.879 | 3/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 3/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 3/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +4.679 | +4.879 | 2/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 2/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 2/D-E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +1.179 | +1.379 | 5/E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +3.579 | +3.779 | 5/E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +1.179 | +1.379 | 5/A | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +3.579 | +3.779 | 5/A | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 1 | +2.679 | +2.722 | 2/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +0.179 | +0.222 | 2/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +2.679 | +2.722 | 4/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +0.179 | +0.222 | 4/A | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +2.679 | +2.722 | 2/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +0.179 | +0.222 | 2/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +2.679 | +2.722 | 4/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +0.179 | +0.222 | 4/E | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 3.4 | +0.079 | +0.179 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +1.179 | +1.379 | 1/E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +3.579 | +3.779 | 1/E | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 1/A | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 8.4 | +6.280 | +6.730 | 5/C | G0(?) | 4
Steel Assembly | RIGID_FRAME | 28.4 | +0.179 | +0.279 | 5/B-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.4 | +2.679 | +2.779 | 5/B-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.4 | +4.856 | +4.956 | 5/B-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.4 | +4.856 | +4.956 | 1/B-D | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +4.809 | +4.856 | 5/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +4.856 | +4.956 | 5/A-B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 5/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +2.679 | +2.779 | 5/A-B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 5/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +0.179 | +0.279 | 5/A-B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +4.809 | +4.856 | 5/D-E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +4.856 | +4.956 | 5/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 5/D-E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +2.679 | +2.779 | 5/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 5/D-E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +0.179 | +0.279 | 5/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +4.809 | +4.856 | 1/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +4.856 | +4.956 | 1/A-B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 1/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +2.679 | +2.779 | 1/A-B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 1/A-B | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +0.179 | +0.279 | 1/A-B | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +4.809 | +4.856 | 1/D-E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +4.856 | +4.956 | 1/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 2 | +2.632 | +2.679 | 1/D | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +2.632 | +2.679 | 1/D-E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 24.9 | +2.679 | +2.779 | 1/D-E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 1/D-E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +0.132 | +0.179 | 1/A | AT0(?) | 170.003
Steel Assembly | RIGID_FRAME | 24.9 | +0.179 | +0.279 | 1/D-E | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +0.000 | +0.054 | 1/B | CO0(?) | 54
2 x Steel Assembly | RIGID_FRAME | 1.3 | +0.000 | +0.054 | 1/D | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 27.1 | +5.760 | +5.973 | 4-5/A-B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 5/A | G0(?) | 4
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 5/E | G0(?) | 4
Steel Assembly | RIGID_FRAME | 13.5 | +4.904 | +5.667 | 4/D-E | G0(?) | 4
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 1/A | G0(?) | 4
Steel Assembly | RIGID_FRAME | 13.5 | +4.904 | +5.667 | 2/A-B | G0(?) | 4
Steel Assembly | RIGID_FRAME | 13.5 | +4.904 | +5.667 | 3/A-B | G0(?) | 4
Steel Assembly | RIGID_FRAME | 13.5 | +4.904 | +5.667 | 4/A-B | G0(?) | 4
Steel Assembly | RIGID_FRAME | 2.8 | +1.179 | +1.379 | 1/A | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 2.8 | +3.579 | +3.779 | 1/A | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 6.9 | +5.054 | +5.636 | 1/E | G0(?) | 4
Steel Assembly | RIGID_FRAME | 1 | +5.258 | +5.287 | 3/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 1 | +5.258 | +5.287 | 4/E | AT0(?) | 270.003
Steel Assembly | RIGID_FRAME | 28.3 | +5.256 | +5.356 | 3-4/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +2.679 | +2.779 | 3-4/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +0.179 | +0.279 | 3-4/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1 | +5.258 | +5.287 | 3/A | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 3/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1 | +5.258 | +5.287 | 4/A | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 4/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 28.3 | +5.256 | +5.356 | 3-4/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +2.679 | +2.779 | 3-4/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +0.179 | +0.279 | 3-4/A | LS0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 28.3 | +6.504 | +6.717 | 3-4/C | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +6.126 | +6.339 | 3-4/D | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +5.760 | +5.973 | 3-4/D-E | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +5.383 | +5.596 | 3-4/E | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +6.126 | +6.339 | 3-4/B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +5.760 | +5.973 | 3-4/A-B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 28.3 | +5.383 | +5.596 | 3-4/A | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.519 | +6.724 | 1/C | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 27.7 | +6.504 | +6.717 | 1-2/C | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +6.126 | +6.339 | 1-2/D | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +5.760 | +5.973 | 1-2/D-E | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 2/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +5.383 | +5.596 | 1-2/E | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 1/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +5.760 | +5.973 | 1-2/A-B | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 2/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +5.383 | +5.596 | 1-2/A | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +5.398 | +5.603 | 1/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 1/A | AT0(?) | 166.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 2/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +5.256 | +5.356 | 1-2/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +2.679 | +2.779 | 1-2/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +0.179 | +0.279 | 1-2/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1 | +5.258 | +5.287 | 2/E | AT0(?) | 270.003
2 x Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 2/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.7 | +5.256 | +5.356 | 1-2/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +2.679 | +2.779 | 1-2/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 3/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.1 | +0.179 | +0.279 | 2-3/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +2.679 | +2.779 | 2-3/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.256 | +5.356 | 2-3/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 2/E | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 3.4 | +4.679 | +4.879 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 2/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 2/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 11.6 | +6.085 | +6.730 | 2/C | G0(?) | 4
2 x Steel Assembly | RIGID_FRAME | 1.3 | +6.519 | +6.724 | 2/C | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.1 | +6.126 | +6.339 | 2-3/D | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.760 | +5.973 | 2-3/D-E | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 27.1 | +6.504 | +6.717 | 2-3/C | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.383 | +5.596 | 2-3/E | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 3/E | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 3/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 11.6 | +6.085 | +6.730 | 3/C | G0(?) | 4
Steel Assembly | RIGID_FRAME | 27.1 | +0.179 | +0.279 | 2-3/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +2.679 | +2.779 | 2-3/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.256 | +5.356 | 2-3/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +6.126 | +6.339 | 2-3/B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.760 | +5.973 | 2-3/A-B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.383 | +5.596 | 2-3/A | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 8.4 | +6.280 | +6.730 | 1/C | G0(?) | 4
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 4/E | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.1 | +0.179 | +0.279 | 4-5/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +2.679 | +2.779 | 4-5/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.256 | +5.356 | 4-5/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 4/E | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 3.4 | +4.679 | +4.879 | 4/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 0.8 | +0.000 | +0.054 | 4/A | CO0(?) | 54
Steel Assembly | RIGID_FRAME | 3.4 | +1.179 | +1.379 | 4/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 3.4 | +3.579 | +3.779 | 4/A-B | RA0(?) | 100
Steel Assembly | RIGID_FRAME | 11.6 | +6.085 | +6.730 | 4/C | G0(?) | 4
Steel Assembly | RIGID_FRAME | 27.1 | +6.126 | +6.339 | 4-5/D | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.760 | +5.973 | 4-5/D-E | PA0(?) | 100
2 x Steel Assembly | RIGID_FRAME | 27.1 | +6.504 | +6.717 | 4-5/C | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.383 | +5.596 | 4-5/E | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.7 | +0.179 | +0.279 | 1-2/E | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 1.3 | +5.209 | +5.256 | 5/A | AT0(?) | 166.003
Steel Assembly | RIGID_FRAME | 27.1 | +0.179 | +0.279 | 4-5/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +2.679 | +2.779 | 4-5/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.256 | +5.356 | 4-5/A | LS0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +6.126 | +6.339 | 4-5/B | PA0(?) | 100
Steel Assembly | RIGID_FRAME | 27.1 | +5.383 | +5.596 | 4-5/A | PA0(?) | 100

# IfcFooting: 1000*1000 (10)
In: Undefined
Description: 1000*1000; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -1.000; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 241; Classe: 8; Matériau: VERRE; Profil: 1000*1000; Nom: SEMELLE
Tekla Quantités - Poids: 2530 kg; Volume: 1 m3; Surface supérieure totale: 1 m2; Surface par tonne: 2.4 m2; Surface nette: 6 m2; Hauteur: 1000 mm; Largeur: 1000 mm; Longueur: 1000 mm
BaseQuantities - Length: 1000 mm; OuterSurfaceArea: 6 m2; GrossSurfaceArea: 6 m2; CrossSectionArea: 1 m2; NetVolume: 1 m3; GrossVolume: 1 m3; NetWeight: 2530 kg; GrossWeight: 2530 kg; Width: 1000 mm; Height: 1000 mm

# IfcFooting: 275*275 (4)
In: Undefined
Description: 275*275; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.450; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 241; Classe: 8; Matériau: VERRE; Profil: 275*275; Nom: SEMELLE
Tekla Quantités - Poids: 86.1 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 7.5 m2; Surface nette: 0.6 m2; Hauteur: 275 mm; Largeur: 275 mm; Longueur: 450 mm
BaseQuantities - Length: 450 mm; OuterSurfaceArea: 0.64625 m2; GrossSurfaceArea: 0.64625 m2; CrossSectionArea: 0.075625 m2; NetVolume: 0.0340312 m3; GrossVolume: 0.0340312 m3; NetWeight: 86.0991 kg; GrossWeight: 86.0991 kg; Width: 275 mm; Height: 275 mm

# IfcFooting: 650*130 (10)
In: Undefined
Description: 650*130; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.650; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 241; Classe: 8; Matériau: VERRE; Profil: 650*130; Nom: SEMELLE
Tekla Quantités - Poids: 139 kg; Volume: 0.1 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 8.5 m2; Surface nette: 1.2 m2; Hauteur: 650 mm; Largeur: 130 mm; Longueur: 650 mm
BaseQuantities - Length: 650 mm; OuterSurfaceArea: 1.183 m2; GrossSurfaceArea: 1.183 m2; CrossSectionArea: 0.0845 m2; NetVolume: 0.054925 m3; GrossVolume: 0.054925 m3; NetWeight: 138.96 kg; GrossWeight: 138.96 kg; Width: 130 mm; Height: 650 mm

# IfcFooting: 800*800 (4)
In: Undefined
Description: 800*800; Material: MISCELLANEOUS/VERRE
Tekla Commun - Niveau bas: -0.800; Niveau haut: -0.000; Repère de pièce: S0(?); Repère d'assemblage: S0(?); Phase: 241; Classe: 8; Matériau: VERRE; Profil: 800*800; Nom: SEMELLE
Tekla Quantités - Poids: 1295.4 kg; Volume: 0.5 m3; Surface supérieure totale: 0.6 m2; Surface par tonne: 3 m2; Surface nette: 3.8 m2; Hauteur: 800 mm; Largeur: 800 mm; Longueur: 800 mm
BaseQuantities - Length: 800 mm; OuterSurfaceArea: 3.84 m2; GrossSurfaceArea: 3.84 m2; CrossSectionArea: 0.64 m2; NetVolume: 0.512 m3; GrossVolume: 0.512 m3; NetWeight: 1295.36 kg; GrossWeight: 1295.36 kg; Width: 800 mm; Height: 800 mm

# IfcMechanicalFastener: Bolt assembly (11192)
In: Undefined
NominalDiameter: 12 mm; Material: 8.8
Tekla Boulons - Diamètre rondelle: 12 mm; Type rondelle: PLA-8.8; Nom rondelle: RONDELLE-M12-PLA-8.8; Type écrou: E-8.8; Nom écrou: ECROU-M12-E-8.8; Trou oblong Y: 0 mm; Trou oblong X: 0 mm; Diamètre du trou: 14 mm; Lieu Boulonnage: Montage; Diamètre: 12 mm; Standard: 8.8; Nom: M12*25
Name | NominalLength (mm) | Quantité de rondelle | Quantité d'écrou | Quantité | Longueur (mm)
122 x Bolt assembly | 25 | 0 | 4 | 4 | 25
1367 x Bolt assembly | 25 | 0 | 2 | 2 | 25
20 x Bolt assembly | 4 | 0 | 0 | 4 | 4
148 x Bolt assembly | 4 | 0 | 0 | 2 | 4
584 x Bolt assembly | 25 | 0 | 1 | 1 | 25
20 x Bolt assembly | 4.00002 | 0 | 0 | 2 | 4
6324 x Bolt assembly | 2 | 0 | 0 | 2 | 2
260 x Bolt assembly | 2 | 0 | 0 | 1 | 2
601 x Bolt assembly | 1.5 | 0 | 0 | 2 | 1.5
1742 x Bolt assembly | 1.5 | 0 | 0 | 1 | 1.5
4 x Bolt assembly | 25 | 4 | 4 | 4 | 25

# IfcMember: SADEF-C+200X1.50 (118)
In: Undefined
Description: SADEF-C+200X1.50
Tekla Commun - Profil: SADEF-C+200X1.50
Tekla Quantités - Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 151.5 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000723 m2
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Matériau | Nom | Poids (kg) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3) | NetWeight (kg) | GrossWeight (kg)
2 x ARBA | STEEL/Steel_Undefined | +0.255 | +2.695 | A0(?) | 61 | 6 | Steel_Undefined | ARBA | 18.7 | 3.3 | 3300.1 | 3300.05 | 2.83804 | 0.00249484 | 0.00238594 | 19.5845 | 18.7296
2 x ARBA | STEEL/Steel_Undefined | +2.712 | +5.146 | A0(?) | 61 | 6 | Steel_Undefined | ARBA | 18.7 | 3.3 | 3291.4 | 3291.43 | 2.83063 | 0.00248832 | 0.0023797 | 19.5333 | 18.6806
2 x ARBA | STEEL/Steel_Undefined | +0.255 | +5.146 | A0(?) | 61 | 6 | Steel_Undefined | ARBA | 38.1 | 6.8 | 6711.5 | 6711.53 | 5.77191 | 0.00507391 | 0.00485243 | 39.8302 | 38.0916
2 x POUTRE | STEEL/S235JR | +5.479 | +5.988 | A0(?) | 60 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
2 x POUTRE | STEEL/S235JR | +5.845 | +6.354 | A0(?) | 60 | 99 | S235JR | POUTRE | 2.8 | 0.4 | 500 | 500 | 0.43 | 0.000378 | 0.0003615 | 2.9673 | 2.83777
4 x POUTRE | STEEL/S235JR | +5.746 | +6.354 | A0(?) | 58 | 99 | S235JR | POUTRE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x POUTRE | STEEL/S235JR | +5.380 | +5.988 | A0(?) | 58 | 99 | S235JR | POUTRE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
4 x POUTRE | STEEL/S235JR | +5.746 | +6.354 | A0(?) | 57 | 99 | S235JR | POUTRE | 3.4 | 0.6 | 600 | 600 | 0.516 | 0.0004536 | 0.0004338 | 3.56076 | 3.40533
